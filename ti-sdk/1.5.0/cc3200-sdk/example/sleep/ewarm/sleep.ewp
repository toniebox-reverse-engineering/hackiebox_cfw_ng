# IAR project sleep.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\inc/c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sleep.bin
  ILINK.IlinkOutputFile: sleep.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c pinmux.c
    ../../common/: startup_ewarm.c timer_if.c uart_if.c wdt_if.c
