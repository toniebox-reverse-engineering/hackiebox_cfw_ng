<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\simplelink_extlib\flc\ewarm\flc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\simplelink_extlib\ota\ewarm\ota.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ota_update_os.ewp</path>
  </project>
  <batchBuild/>
</workspace>


