# IAR project mqtt_server.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\..\common\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\simplelink\; ..\..\..\simplelink\source; ..\..\..\simplelink\include; ..\..\..\oslib\; ..\..\..\third_party\FreeRTOS\source\include\; ..\..\..\third_party\FreeRTOS\source\; ..\..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4; ..\..\..\netapps\mqtt\include; ..\..\..\netapps\mqtt\common; ..\..\..\netapps\mqtt\platform; ..\..\..\simplelink_extlib\provisioninglib\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mqtt_server.bin
  ILINK.IlinkOutputFile: mqtt_client_server.out
  ILINK.IlinkConfigDefines: Flash=0; CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ..\..\..\driverlib\ewarm\Release\Exe\driverlib.a; ..\..\..\simplelink\ewarm\OS\Exe\simplelink.a; ..\..\..\oslib\ewarm\free_rtos\Exe\free_rtos.a; ..\..\..\netapps\mqtt\ewarm\client_server\Exe\mqtt.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../common/: button_if.c gpio_if.c network_common.c network_if.c startup_ewarm.c timer_if.c uart_if.c
    ../: main.c pinmux.c server_client_cbs.c
