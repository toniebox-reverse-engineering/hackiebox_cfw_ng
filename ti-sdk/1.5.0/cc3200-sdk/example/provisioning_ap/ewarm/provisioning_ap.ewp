# IAR project provisioning_ap.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: provisioning_ap.bin
  ILINK.IlinkOutputFile: provisioning_ap.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../simplelink/ewarm/NON_OS/Exe/simplelink.a; ../../../simplelink_extlib/provisioninglib/ewarm/Release/Exe/provisioninglib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../common/: gpio_if.c startup_ewarm.c timer_if.c uart_if.c
    ../: main.c pinmux.c
