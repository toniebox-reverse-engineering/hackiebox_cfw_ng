<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\watchdog_system_demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


