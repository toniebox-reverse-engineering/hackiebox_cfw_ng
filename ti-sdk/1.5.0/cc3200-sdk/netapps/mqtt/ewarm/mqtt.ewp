# IAR project mqtt.ewp, settings and files
configuration client (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; DEBUG
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ..\client\; ..\sl\; ..\common\; ..\platform\; ..\include\; ..\..\..\simplelink\include\; ..\..\..\oslib\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\simplelink_extlib\provisioninglib\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: mqtt.out
configuration client_server (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.CoreVariant: 39
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCIncludePath2: ..\client\; ..\sl\; ..\common\; ..\platform\; ..\include\; ..\server\; ..\platform\; ..\..\..\simplelink\include\; ..\..\..\oslib\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\simplelink_extlib\provisioninglib\
  ICCARM.CCOptLevel: 3
  group (top)
    ../platform/: cc32xx_platform.c cc32xx_sl_net.c
    ../server/: client_mgmt.c server_core.c server_pkts.c server_plug.c server_util.c
    ../client/: mqtt_client.c
    ../common/: mqtt_common.c
    ../sl/: sl_mqtt_client.c sl_mqtt_server.c
